# Keil uVision project SVM_II_BootLoader_v22.uvprojx, settings and files
target SVM_II_BL_RUN (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SVM_II_BootLoader_v22 +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: .\CORE;.\OBJ;.\USER;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\HALLIB\STM32F4xx_HAL_Driver\Inc;.\HARDWARE\LED;.\HARDWARE\RTC;.\HARDWARE\INP;.\HARDWARE\MOTOR;.\HARDWARE\TIMER;.\HARDWARE\CAN;.\HARDWARE\PCF8574;.\HARDWARE\IIC
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c programm.c crc32.c
  group CORE
    ./CORE/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm4.h mpu_armv7.h startup_stm32f407xx.s
  group HALLIB
    ./HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group HARDWARE
    ./HARDWARE/LED/: led.c
    ./HARDWARE/RTC/: rtc.c
    ./HARDWARE/INP/: INP.c
    ./HARDWARE/MOTOR/: motor.c
    ./HARDWARE/TIMER/: timer.c
    ./HARDWARE/CAN/: can.c
    ./HARDWARE/PCF8574/: pcf8574.c
    ./HARDWARE/IIC/: myiic.c
  group README
    ./: Readme.txt
target SVM_II_BL_DEBUG (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: as above
  output: SVM_II_BootLoader_t01 +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx,DEBUG
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
