# Keil uVision project SVM_II_Main_v117.uvprojx, settings and files
target SVM_II_Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SVM_II_Main_v117 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\USER\Inc;.\FWLIB\inc;.\CMSIS;.\xmodem;.\HARDWARE\LED;.\HARDWARE\TIMER;.\HARDWARE\VNCII;.\HARDWARE\USART;.\HARDWARE\DMA;.\HARDWARE\INP;.\HARDWARE\PWM;.\HARDWARE\BEEPER;.\HARDWARE\IIC;.\HARDWARE\24CXX;.\HARDWARE\EEPROM;.\HARDWARE\CAN;.\HARDWARE\RTC;.\HARDWARE\MOTOR;.\HARDWARE\ETHERNET;.\LWIP;.\LWIP\arch;.\LWIP\lwip_app\tcp_client_demo;.\LWIP\lwip_app\lwip_comm;.\LWIP\lwip_app\udp_demo;.\LWIP\lwip-1.4.1\src\include;.\LWIP\lwip-1.4.1\src\include\ipv4;.\LWIP\lwip-1.4.1\src\include\lwip;.\LWIP\lwip-1.4.1\src\include\netif;.\MALLOC
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./CMSIS/: RTX_Conf_CM.c RTX_CM4.lib system_stm32f4xx.c
  group CORE
    ./CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ./FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4x7_eth.c
  group HARDWARE
    ./HARDWARE/24CXX/: 24cxx.c
    ./HARDWARE/BEEPER/: beeper.c
    ./HARDWARE/CAN/: can.c
    ./HARDWARE/DMA/: dma.c
    ./HARDWARE/EEPROM/: eeprom.c
    ./HARDWARE/INP/: INP.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/IIC/: myiic.c
    ./HARDWARE/PWM/: pwm.c
    ./HARDWARE/TIMER/: timer.c
    ./HARDWARE/USART/: usart.c
    ./HARDWARE/VNCII/: vinculum.c
    ./HARDWARE/RTC/: rtc.c
    ./HARDWARE/MOTOR/: motor.c
    ./HARDWARE/ETHERNET/: lan8720.c
  group USER
    ./USER/: main.c Communication.c version.c utils.c system.c crc32.c timedate.c updater.c
  group xmodem
    ./xmodem/: ymodem.c
  group MALLOC
    ./MALLOC/: malloc.c
  group LWIP-APP
    ./LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ./LWIP/lwip_app/tcp_client_demo/: tcp_client_demo.c
    ./LWIP/lwip_app/udp_demo/: udp_demo.c
  group LWIP-NETIF
    ./LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP-CORE
    ./LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ./LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP-ARCH
    ./LWIP/arch/: sys_arch.c
  group LWIP-API
    ./LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
target SVM_II_Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: as above
  output: SVM_II_Main_Debug +hex
  AfterMake: CopyHex_Flash.bat
  AfterMake: fromelf.exe --bin -o ./@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,DEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
