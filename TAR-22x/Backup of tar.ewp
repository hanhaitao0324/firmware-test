# IAR project Backup of tar.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x40
  General.SCCStackSize: 0x200
  General.SCRStackSize: 128
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m128 ATmega128
  ICCAVR.CCDefines: DEVICE_TAR
  ICCAVR.newCCIncludePaths: Include\
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128.xcl
  XLINK.XExtraOptions: -DUpdate=0x1FD00; -Ointel-extended,(CODE)=debug\exe\TAR\TAR_v222code.hex; -Ointel-extended,(XDATA)=debug\exe\TAR\TAR_v222ee.hex
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.GenDeviceSelectMenu: 0 -v0, Max 256 byte data, 8 Kbyte code
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
  group (top)
    C/: confmenu_tar.c control.c crc.c edit.c eeprom_tar.c eeprom_utils.c ekey.c engineering_tar.c external.c font.c global.c kbd.c led.c main.c menu.c motor.c parser_tar.c printrtc.c rep_strings_tar.c report_tar.c rs485.c sound.c spi.c strings.c syserror.c test_tar.c testsetup_tar.c timedate.c timer.c updater.c usb.c version_tar.c xtea.c
