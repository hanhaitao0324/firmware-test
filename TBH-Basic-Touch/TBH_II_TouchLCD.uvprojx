# Keil uVision project TBH_II_TouchLCD.uvprojx, settings and files
target DEBUG (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TBH_II_Touch_v00_10 +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1,PCB_DEBUG
  c include: .\CORE;.\OBJ;.\USER;.\HALLIB\STM32F4xx_HAL_Driver\Inc;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\HARDWARE\LED;.\HARDWARE\KEY;.\HARDWARE\LCD;.\HARDWARE\SDRAM;.\HARDWARE\TOUCH;.\HARDWARE\24CXX;.\HARDWARE\IIC;.\HARDWARE\RTC;.\HARDWARE\TIMER;.\HARDWARE\CAN;.\HARDWARE\SDIO;.\HARDWARE\NAND;.\HARDWARE\W25QXX;.\HARDWARE\SPI;.\IMAGE2LCD;.\DSP_LIB\Include;.\EMWIN\STemWin\Config;.\EMWIN\STemWin\inc;.\MALLOC;.\FATFS\src;.\FATFS\exfuns;.\TEXT;.\EMWIN\STemWin\inc
  memory RVCT4: ROM 0x8000000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c stm32f4xx_it.c system_stm32f4xx.c version.c
  group CORE
    ./CORE/: cmsis_armcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f429xx.s
  group HALLIB
    ./HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_sdram.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_spi.c
  group HARDWARE
    ./HARDWARE/LED/: led.c
    ./HARDWARE/SDRAM/: sdram.c
    ./HARDWARE/LCD/: ltdc.c tftlcd.c
    ./HARDWARE/TOUCH/: touch.c ctiic.c gt911.c ft5206.c gt9147.c gt9271.c ott2001a.c
    ./HARDWARE/24CXX/: 24cxx.c
    ./HARDWARE/IIC/: myiic.c
    ./HARDWARE/RTC/: rtc.c
    ./HARDWARE/TIMER/: timer.c
    ./HARDWARE/CAN/: can.c
    ./HARDWARE/SDIO/: sdio_sdcard.c
    ./HARDWARE/NAND/: ftl.c nand.c nandtester.c
    ./HARDWARE/W25QXX/: w25qxx.c
    ./HARDWARE/SPI/: spi.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group DSP_LIB
    ./DSP_LIB/: arm_cortexM4lf_math.lib
  group EMWIN_LIB
    ./EMWIN/STemWin/Lib/: GUI_CM4F_L.lib
  group EMWIN_CONFIG
    ./EMWIN/STemWin/OS/: GUI_X.c
    ./EMWIN/STemWin/Config/: GUIConf.c LCDConf_Lin_Template.c GUI_X_Touch_Analog.c
  group SVM_FONT
    ./EMWIN/SvmFont/: Helvetica Neue Bold48.c Roboto Bold34.c Roboto Medium20.c Roboto Medium22.c Roboto Medium24.c Roboto Regular27.c Roboto Bold28.c
  group KEYPAD
    ./EMWIN/KeyPad/: KP_BackSpace.c KP_Clear.c KP_Empty.c KP_Enter.c KP_ShiftL.c KP_ShiftR.c KP_Space.c KP_To123.c KP_ToABC.c
  group BMP
    ./EMWIN/BMP/: GGB_035.c SCB_039.c logo_grey_235_48.c erweka-positiv-5cm.c
  group MALLOC
    ./MALLOC/: malloc.c
  group FATFS
    ./FATFS/exfuns/: exfuns.c fattester.c mycc936.c
    ./FATFS/src/: diskio.c ff.c
  group TEXT
    ./TEXT/: text.c fontupd.c
target RELEASE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: as above
  output: TBH_II_Touch_v01_00 +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1
  c include: .\CORE;.\OBJ;.\USER;.\HALLIB\STM32F4xx_HAL_Driver\Inc;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\HARDWARE\LED;.\HARDWARE\KEY;.\HARDWARE\LCD;.\HARDWARE\SDRAM;.\HARDWARE\TOUCH;.\HARDWARE\24CXX;.\HARDWARE\IIC;.\HARDWARE\RTC;.\HARDWARE\TIMER;.\HARDWARE\CAN;.\HARDWARE\SDIO;.\HARDWARE\NAND;.\HARDWARE\W25QXX;.\HARDWARE\SPI;.\IMAGE2LCD;.\DSP_LIB\Include;.\EMWIN\STemWin\Config;.\EMWIN\STemWin\inc;.\MALLOC;.\FATFS\src;.\FATFS\exfuns;.\TEXT
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target OLDLCD (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: as above
  output: TBH_II_Touch_OldLCD +hex
  AfterMake: CopyHex_Flash.bat
  AfterMake: C:\Program Files\KEIL\MDK536\ARM\ARMCC\bin\fromelf.exe --bin -o tar_II_touch_test.bin OBJ\TAR_II_Touch_v*.axf
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1,OLD_LCD
  c include: as above
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
