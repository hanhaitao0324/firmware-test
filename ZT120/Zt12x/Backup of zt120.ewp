# IAR project Backup of zt120.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x40
  General.SCCStackSize: 0x400
  General.SCRStackSize: 128
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m128a ATmega128A
  ICCAVR.newCCIncludePaths: Include\
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128a.xcl
  XLINK.XExtraOptions: -DUpdate=0x1FD00; -Ointel-extended,(CODE)=debug\exe\zt120v101_code.hex; -Ointel-extended,(XDATA)=debug\exe\zt_ee.hex
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x10
  General.SCRStackSize: 64
  General.GenDeviceSelectMenu: m128 ATmega128
  ICCAVR.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128.xcl
  group (top)
    C/: adc.c calibrate.c confmenu.c control.c crc.c dhc.c dropper.c edit.c eeprom.c ekey.c engineering.c external.c font.c fram.c global.c heater.c kbd.c led.c lifter.c main.c menu.c motor.c parser.c printrtc.c report.c rs232.c rs485.c sampler.c sound.c spi.c stepper.c strings.c syserror.c temp.c test.c testsetup.c timedate.c timer.c updater.c usb.c utils.c version.c xtea.c
