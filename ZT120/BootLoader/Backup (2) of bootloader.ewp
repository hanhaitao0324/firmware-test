# IAR project Backup (2) of bootloader.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m128 ATmega128
  ICCAVR.newCCIncludePaths: include\; Asm\
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 0
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: link.xcl
  XLINK.XExtraOptions: -DUpdate=0x1FD00; -Ointel-extended,(CODE)=debug\exe\zt120_bootloader.hex
configuration Release (AVR)
  as the first configuration, except:
  General.GenDeviceSelectMenu: m3290 ATmega3290
  ICCAVR.CCOptStrategy: 1
  group (top)
    Asm/: cstartup.s90
    ./: link.xcl
    C/: main.c usb.c
