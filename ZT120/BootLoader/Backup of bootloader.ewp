# IAR project Backup of bootloader.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.newCCIncludePaths: include\; Asm\
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: link.xcl
configuration Release (AVR)
  as the first configuration, except:
  group (top)
    Asm/: cstartup.s90
    ./: link.xcl
    C/: main.c usb.c
