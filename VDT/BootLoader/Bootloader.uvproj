# Keil uVision project Bootloader.uvproj, settings and files
target Bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: VDT_Bootloader +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F10X_MD
  c include: .\Include;.\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0xc00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./: startup_stm32f10x_md.s
  group System
    ./C/: core_cm3.c system_stm32f10x.c
  group Hardware
    ./C/: serial.c programm.c
  group App
    ./C/: main.c crc32.c
  group Documentation
    ./: History Bootloader.txt
target Bootloader_Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: VDT_Bootloader_Debug +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F10X_MD, BL_DEBUG
  c include: .\Include;.\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0xc00
  memory RVCT9: RAM 0x20000000 size 0x5000
