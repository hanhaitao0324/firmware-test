# Keil uVision project VDT_v2130.uvprojx, settings and files
target VDT-Debug (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: VDT_Debug +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER, BEEP_OFF
  c include: .\Includes;.\StdPeriph_Driver\inc;.\;.\CMSIS
  asm misc: --fpmode=fast
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: RTX_Conf_CM.c system_stm32f10x.c RTX_CM3.lib startup_stm32f10x_md.s
  group Source
    ./Source/: main.c utils.c font.c Timer.c Communication.c LicManagement.c crc32.c PrintErgeb.c PrintOut.c timedate.c PrintProt.c version.c
    ./source/: system.c rtc.c
  group Documentation
    ./: History FW.txt
  group Hardware
    ./Hardware/: spi.c led.c kbd.c beeper.c uart.c eeprom.c mcp3201.c io.c vinculum.c m24xx.c
  group StdDrivers
    ./StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group xmodem
    ./xmodem/: ymodem.c
target VDT-Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: VDT_v2130 +hex
  AfterMake: CopyHex.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER, BOOT
  c include: .\Includes;.\StdPeriph_Driver\inc;.\;.\CMSIS
  memory RVCT4: ROM 0x8001000 size 0x1f000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.5.0
